<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>noise_type</key><value>analog.GR_UNIFORM</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>61</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>13</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>barchart_vector_sink_f</key>
<param><key>id</key><value>barchart_vector_sink_f_0</value></param>
<param><key>autoscale</key><value>False</value></param>
<param><key>grid</key><value>False</value></param>
<param><key>name</key><value>"A Fancy Graph Title"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>ref_level</key><value>5</value></param>
<param><key>alpha1</key><value>0.5</value></param>
<param><key>color1</key><value>"yellow"</value></param>
<param><key>label1</key><value>Input 1</value></param>
<param><key>width1</key><value>1</value></param>
<param><key>alpha2</key><value>0.5</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Input 2</value></param>
<param><key>width2</key><value>1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>vlen</key><value>16</value></param>
<param><key>x_axis_label</key><value>"Category"</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1</value></param>
<param><key>x_units</key><value>""</value></param>
<param><key>ymax</key><value>5</value></param>
<param><key>ymin</key><value>-5</value></param>
<param><key>y_axis_label</key><value>"Amplitude"</value></param>
<param><key>y_units</key><value>""</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>16</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>16</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>16</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>16</value></param>
</block>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fastnoise_source_x_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>barchart_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>barchart_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
